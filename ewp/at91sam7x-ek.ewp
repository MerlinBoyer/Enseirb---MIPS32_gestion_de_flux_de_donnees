# IAR project at91sam7x-ek.ewp, settings and files
configuration at91sam7x256_sram (ARM, debug)
  General.OGChipSelectEditMenu: at91sam7x256 Atmel at91sam7x256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: at91sam7x256; sram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib; ..\..\..\at91lib/components; ..\..\..\at91lib/boards/at91sam7x-ek
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam7x256; sram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7x-ek
  OBJCOPY.OOCOutputFile: at91sam7x256_sram.bin
  ILINK.IlinkOutputFile: at91sam7x256_sram.out
  ILINK.IlinkIcfFile: at91lib\boards\at91sam7x-ek\at91sam7x256\sram
  ILINK.IlinkProgramEntryLabel: resetHandler
  group init
    at91lib/boards/at91sam7x-ek/: board_cstartup_iar.s board_lowlevel.c board_memories.c
  group Software
    ../: main.c
